# Keil uVision project GD32_CIMC_GdLib_Bootloader.uvprojx, settings and files
target 2026837587_Bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CIMC_GD32_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Driver\led;..\Driver\intflash;..\Driver\rs485;..\Driver\OLED;..\Driver\usart2;..\CMSIS\GD\GD32F4xx\Include;..\Function;..\Protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Driver/led
    ../Driver/led/: LED.c LED.h
  group Driver/rs485
    ../Driver/rs485/: rs485.c rs485.h
  group Driver/usart2
    ../Driver/usart2/: usart2.c usart2.h
  group Driver/OLED
    ../Driver/OLED/: OLED.c OLED.h OLEDFonts.h
  group Driver/intflash
    ../Driver/intflash/: intflash.c intflash.h
  group Protocol
    ../Protocol/: proto_cmd.h protocol.c protocol.h proto_crc.c proto_crc.h proto_frame.c proto_frame.h proto_hex.c proto_hex.h
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Function
    ../Function/: Function.c Function.h bootloader.c bootloader.h
  group Readme
    ../01 Readme/: Readme.txt
software components: CMSIS:CORE 5.1.1
